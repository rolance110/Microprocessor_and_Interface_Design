# Keil uVision project lab1.2.1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lab1.2.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LAB1_2_1.A51
